<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\GCC_FreeRTos_VET6.ewp</path>
  </project>
  <batchBuild />
</workspace>
